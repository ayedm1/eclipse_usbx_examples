# IAR project demo_usbx.ewp, settings and files
configuration demo_device_storage_standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747I-DISCO_M7 ST STM32H747I-DISCO_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; UX_STANDALONE; UX_PERIODIC_RATE=1000; HID_MOUSE; UX_DEVICE_SIDE_ONLY; UX_DEVICE_BIDIRECTIONAL_ENDPOINT_SUPPORT; UX_MAX_SLAVE_LUN=2
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/USBX/App; ../CM7/USBX/Target; ..\..\eclipse_usbx\ports\generic\inc; ..\..\eclipse_usbx\common\core\inc; ..\..\eclipse_usbx\common\usbx_device_classes\inc; ..\..\supported-platforms\stm32\usbx\usbx_stm32_device_controllers; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy; ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo_device_hid_mouse_CM7.hex
  ILINK.IlinkOutputFile: demo_device_hid_mouse_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_rw_sram1_CM7.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h747xx_CM7.s
  group Application/User/CM7/Core
    ../CM7/Core/Src/: gpio.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c usb_otg.c
  group Application/User/CM7/USBX
    ../../: demo_device_mass_multi_lun_storage_standalone.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../Users/ayed/STM32Cube/Repository/STM32Cube_FW_H7_V1.12.1/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_usb.c
  group Middlewares/USBX/controllers
    ../../supported-platforms/stm32/usbx/usbx_stm32_device_controllers/: ux_dcd_stm32.h ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/core
    ../../eclipse_usbx/common/core/src/: ux_dcd_sim_slave_address_set.c ux_dcd_sim_slave_endpoint_create.c ux_dcd_sim_slave_endpoint_destroy.c ux_dcd_sim_slave_endpoint_reset.c ux_dcd_sim_slave_endpoint_stall.c ux_dcd_sim_slave_endpoint_status.c ux_dcd_sim_slave_frame_number_get.c ux_dcd_sim_slave_function.c ux_dcd_sim_slave_initialize.c ux_dcd_sim_slave_initialize_complete.c ux_dcd_sim_slave_state_change.c ux_dcd_sim_slave_transfer_abort.c ux_dcd_sim_slave_transfer_request.c ux_dcd_sim_slave_transfer_run.c ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_read_run.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_class_dpump_write_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_hcd_sim_host_asynch_queue_process.c ux_hcd_sim_host_asynch_schedule.c ux_hcd_sim_host_asynchronous_endpoint_create.c ux_hcd_sim_host_asynchronous_endpoint_destroy.c ux_hcd_sim_host_controller_disable.c ux_hcd_sim_host_ed_obtain.c ux_hcd_sim_host_ed_td_clean.c ux_hcd_sim_host_endpoint_reset.c ux_hcd_sim_host_entry.c ux_hcd_sim_host_frame_number_get.c ux_hcd_sim_host_frame_number_set.c ux_hcd_sim_host_initialize.c ux_hcd_sim_host_interrupt_endpoint_create.c ux_hcd_sim_host_iso_queue_process.c ux_hcd_sim_host_iso_schedule.c ux_hcd_sim_host_isochronous_endpoint_create.c ux_hcd_sim_host_isochronous_td_obtain.c ux_hcd_sim_host_least_traffic_list_get.c ux_hcd_sim_host_periodic_endpoint_destroy.c ux_hcd_sim_host_periodic_schedule.c ux_hcd_sim_host_periodic_tree_create.c ux_hcd_sim_host_port_reset.c ux_hcd_sim_host_port_status_get.c ux_hcd_sim_host_regular_td_obtain.c ux_hcd_sim_host_request_bulk_transfer.c ux_hcd_sim_host_request_control_transfer.c ux_hcd_sim_host_request_interupt_transfer.c ux_hcd_sim_host_request_isochronous_transfer.c ux_hcd_sim_host_request_transfer.c ux_hcd_sim_host_timer_function.c ux_hcd_sim_host_transaction_schedule.c ux_hcd_sim_host_transfer_abort.c ux_hcd_sim_host_transfer_run.c ux_hcd_sim_host_uninitialize.c ux_host_class_dpump_activate.c ux_host_class_dpump_configure.c ux_host_class_dpump_deactivate.c ux_host_class_dpump_endpoints_get.c ux_host_class_dpump_entry.c ux_host_class_dpump_ioctl.c ux_host_class_dpump_read.c ux_host_class_dpump_write.c ux_host_stack_bandwidth_check.c ux_host_stack_bandwidth_claim.c ux_host_stack_bandwidth_release.c ux_host_stack_class_call.c ux_host_stack_class_device_scan.c ux_host_stack_class_get.c ux_host_stack_class_instance_create.c ux_host_stack_class_instance_destroy.c ux_host_stack_class_instance_get.c ux_host_stack_class_instance_verify.c ux_host_stack_class_interface_scan.c ux_host_stack_class_register.c ux_host_stack_class_unregister.c ux_host_stack_configuration_descriptor_parse.c ux_host_stack_configuration_enumerate.c ux_host_stack_configuration_instance_create.c ux_host_stack_configuration_instance_delete.c ux_host_stack_configuration_interface_get.c ux_host_stack_configuration_interface_scan.c ux_host_stack_configuration_set.c ux_host_stack_delay_ms.c ux_host_stack_device_address_set.c ux_host_stack_device_configuration_activate.c ux_host_stack_device_configuration_deactivate.c ux_host_stack_device_configuration_get.c ux_host_stack_device_configuration_reset.c ux_host_stack_device_configuration_select.c ux_host_stack_device_descriptor_read.c ux_host_stack_device_get.c ux_host_stack_device_remove.c ux_host_stack_device_resources_free.c ux_host_stack_device_string_get.c ux_host_stack_endpoint_instance_create.c ux_host_stack_endpoint_instance_delete.c ux_host_stack_endpoint_reset.c ux_host_stack_endpoint_transfer_abort.c ux_host_stack_enum_thread_entry.c ux_host_stack_hcd_register.c ux_host_stack_hcd_thread_entry.c ux_host_stack_hcd_transfer_request.c ux_host_stack_hcd_unregister.c ux_host_stack_hnp_polling_thread_entry.c ux_host_stack_initialize.c ux_host_stack_interface_endpoint_get.c ux_host_stack_interface_instance_create.c ux_host_stack_interface_instance_delete.c ux_host_stack_interface_set.c ux_host_stack_interface_setting_select.c ux_host_stack_interfaces_scan.c ux_host_stack_new_configuration_create.c ux_host_stack_new_device_create.c ux_host_stack_new_device_get.c ux_host_stack_new_endpoint_create.c ux_host_stack_new_interface_create.c ux_host_stack_rh_change_process.c ux_host_stack_rh_device_extraction.c ux_host_stack_rh_device_insertion.c ux_host_stack_role_swap.c ux_host_stack_tasks_run.c ux_host_stack_transfer_request.c ux_host_stack_transfer_request_abort.c ux_host_stack_transfer_run.c ux_host_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_trace_event_insert.c ux_trace_event_update.c ux_trace_object_register.c ux_trace_object_unregister.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/storage class
    ../../eclipse_usbx/common/usbx_device_classes/src/: ux_device_class_storage_activate.c ux_device_class_storage_control_request.c ux_device_class_storage_csw_send.c ux_device_class_storage_deactivate.c ux_device_class_storage_entry.c ux_device_class_storage_format.c ux_device_class_storage_get_configuration.c ux_device_class_storage_get_performance.c ux_device_class_storage_get_status_notification.c ux_device_class_storage_initialize.c ux_device_class_storage_inquiry.c ux_device_class_storage_mode_select.c ux_device_class_storage_mode_sense.c ux_device_class_storage_prevent_allow_media_removal.c ux_device_class_storage_read.c ux_device_class_storage_read_capacity.c ux_device_class_storage_read_disk_information.c ux_device_class_storage_read_dvd_structure.c ux_device_class_storage_read_format_capacity.c ux_device_class_storage_read_toc.c ux_device_class_storage_report_key.c ux_device_class_storage_request_sense.c ux_device_class_storage_start_stop.c ux_device_class_storage_synchronize_cache.c ux_device_class_storage_tasks_run.c ux_device_class_storage_test_ready.c ux_device_class_storage_thread.c ux_device_class_storage_uninitialize.c ux_device_class_storage_verify.c ux_device_class_storage_write.c
