# IAR project demo_usbx.ewp, settings and files
configuration demo_device_hid_mouse_rtos (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747I-DISCO_M7 ST STM32H747I-DISCO_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; HID_MOUSE; UX_DEVICE_SIDE_ONLY
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/AZURE_RTOS/App; ../CM7/USBX/App; ../CM7/USBX/Target; ..\..\eclipse_usbx\ports\generic\inc; ..\..\eclipse_usbx\common\core\inc; ..\..\eclipse_usbx\common\usbx_device_classes\inc; ..\..\supported-platforms\stm32\usbx\usbx_stm32_device_controllers; ..\..\threadx\common\inc; ..\..\threadx\ports\cortex_m7\iar\inc; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy; ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo_device_hid_mouse_CM7.hex
  ILINK.IlinkOutputFile: demo_device_hid_mouse_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_rw_sram1_CM7.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration demo_device_hid_mouse_standalone (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; UX_STANDALONE; UX_PERIODIC_RATE=1000; HID_MOUSE; UX_DEVICE_SIDE_ONLY
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/USBX/App; ../CM7/USBX/Target; ..\..\eclipse_usbx\ports\generic\inc; ..\..\eclipse_usbx\common\core\inc; ..\..\eclipse_usbx\common\usbx_device_classes\inc; ..\..\supported-platforms\stm32\usbx\usbx_stm32_device_controllers; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy; ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Drivers\CMSIS\Include
configuration demo_device_hid_keyboard_rtos (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; UX_DEVICE_SIDE_ONLY; EXTERNAL_MAIN; HID_KEYBOARD
configuration demo_device_hid_keyboard_standalone (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; UX_DEVICE_SIDE_ONLY; EXTERNAL_MAIN; UX_STANDALONE; UX_PERIODIC_RATE=1000; HID_KEYBOARD
  ICCARM.CCIncludePath2: as above
configuration demo_device_hid_mouse_keyboard_rtos (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; HID_MOUSE; UX_DEVICE_SIDE_ONLY; UX_DEVICE_CLASS_HID_EVENT_BUFFER_LENGT== 9
configuration demo_device_hid_mouse_keyboard_standalone (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; UX_STANDALONE; UX_PERIODIC_RATE=1000; HID_MOUSE; UX_DEVICE_SIDE_ONLY; UX_DEVICE_CLASS_HID_EVENT_BUFFER_LENGTH=9
  ICCARM.CCIncludePath2: as above
configuration demo_device_hid_consumer (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; HID_CONSUMER; UX_DEVICE_SIDE_ONLY
configuration demo_device_hid_custom_standalone (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; UX_STANDALONE; UX_PERIODIC_RATE=1000; HID_CONSUMER; UX_DEVICE_SIDE_ONLY
  ICCARM.CCIncludePath2: as above
configuration demo_device_hid_inout_rtos (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY; EXTERNAL_MAIN; HID_INOUT; UX_DEVICE_SIDE_ONLY; UX_DEVICE_CLASS_HID_INTERRUPT_OUT_SUPPORT; UX_DEVICE_BIDIRECTIONAL_ENDPOINT_SUPPORT
configuration dem_device_hid_inout_standalone (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
configuration demo_device_cdc_acm_rtos (ARM, debug)
  as the first configuration, except:
  group Application/EWARM
    ./: startup_stm32h747xx_CM7.s
  group Application/User/CM7/Core
    ../CM7/Core/Src/: gpio.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c tx_initialize_low_level.S usb_otg.c
  group Application/User/CM7/USBX
    ../../: demo_device_hid_inout_rtos.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../Users/ayed/STM32Cube/Repository/STM32Cube_FW_H7_V1.12.1/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_usb.c
  group Middlewares/ThreadX/core
    ../../threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../threadx/ports/cortex_m7/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Middlewares/USBX/controllers
    ../../supported-platforms/stm32/usbx/usbx_stm32_device_controllers/: ux_dcd_stm32.h ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/core
    ../../eclipse_usbx/common/core/src/: ux_dcd_sim_slave_address_set.c ux_dcd_sim_slave_endpoint_create.c ux_dcd_sim_slave_endpoint_destroy.c ux_dcd_sim_slave_endpoint_reset.c ux_dcd_sim_slave_endpoint_stall.c ux_dcd_sim_slave_endpoint_status.c ux_dcd_sim_slave_frame_number_get.c ux_dcd_sim_slave_function.c ux_dcd_sim_slave_initialize.c ux_dcd_sim_slave_initialize_complete.c ux_dcd_sim_slave_state_change.c ux_dcd_sim_slave_transfer_abort.c ux_dcd_sim_slave_transfer_request.c ux_dcd_sim_slave_transfer_run.c ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_read_run.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_class_dpump_write_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_hcd_sim_host_asynch_queue_process.c ux_hcd_sim_host_asynch_schedule.c ux_hcd_sim_host_asynchronous_endpoint_create.c ux_hcd_sim_host_asynchronous_endpoint_destroy.c ux_hcd_sim_host_controller_disable.c ux_hcd_sim_host_ed_obtain.c ux_hcd_sim_host_ed_td_clean.c ux_hcd_sim_host_endpoint_reset.c ux_hcd_sim_host_entry.c ux_hcd_sim_host_frame_number_get.c ux_hcd_sim_host_frame_number_set.c ux_hcd_sim_host_initialize.c ux_hcd_sim_host_interrupt_endpoint_create.c ux_hcd_sim_host_iso_queue_process.c ux_hcd_sim_host_iso_schedule.c ux_hcd_sim_host_isochronous_endpoint_create.c ux_hcd_sim_host_isochronous_td_obtain.c ux_hcd_sim_host_least_traffic_list_get.c ux_hcd_sim_host_periodic_endpoint_destroy.c ux_hcd_sim_host_periodic_schedule.c ux_hcd_sim_host_periodic_tree_create.c ux_hcd_sim_host_port_reset.c ux_hcd_sim_host_port_status_get.c ux_hcd_sim_host_regular_td_obtain.c ux_hcd_sim_host_request_bulk_transfer.c ux_hcd_sim_host_request_control_transfer.c ux_hcd_sim_host_request_interupt_transfer.c ux_hcd_sim_host_request_isochronous_transfer.c ux_hcd_sim_host_request_transfer.c ux_hcd_sim_host_timer_function.c ux_hcd_sim_host_transaction_schedule.c ux_hcd_sim_host_transfer_abort.c ux_hcd_sim_host_transfer_run.c ux_hcd_sim_host_uninitialize.c ux_host_class_dpump_activate.c ux_host_class_dpump_configure.c ux_host_class_dpump_deactivate.c ux_host_class_dpump_endpoints_get.c ux_host_class_dpump_entry.c ux_host_class_dpump_ioctl.c ux_host_class_dpump_read.c ux_host_class_dpump_write.c ux_host_stack_bandwidth_check.c ux_host_stack_bandwidth_claim.c ux_host_stack_bandwidth_release.c ux_host_stack_class_call.c ux_host_stack_class_device_scan.c ux_host_stack_class_get.c ux_host_stack_class_instance_create.c ux_host_stack_class_instance_destroy.c ux_host_stack_class_instance_get.c ux_host_stack_class_instance_verify.c ux_host_stack_class_interface_scan.c ux_host_stack_class_register.c ux_host_stack_class_unregister.c ux_host_stack_configuration_descriptor_parse.c ux_host_stack_configuration_enumerate.c ux_host_stack_configuration_instance_create.c ux_host_stack_configuration_instance_delete.c ux_host_stack_configuration_interface_get.c ux_host_stack_configuration_interface_scan.c ux_host_stack_configuration_set.c ux_host_stack_delay_ms.c ux_host_stack_device_address_set.c ux_host_stack_device_configuration_activate.c ux_host_stack_device_configuration_deactivate.c ux_host_stack_device_configuration_get.c ux_host_stack_device_configuration_reset.c ux_host_stack_device_configuration_select.c ux_host_stack_device_descriptor_read.c ux_host_stack_device_get.c ux_host_stack_device_remove.c ux_host_stack_device_resources_free.c ux_host_stack_device_string_get.c ux_host_stack_endpoint_instance_create.c ux_host_stack_endpoint_instance_delete.c ux_host_stack_endpoint_reset.c ux_host_stack_endpoint_transfer_abort.c ux_host_stack_enum_thread_entry.c ux_host_stack_hcd_register.c ux_host_stack_hcd_thread_entry.c ux_host_stack_hcd_transfer_request.c ux_host_stack_hcd_unregister.c ux_host_stack_hnp_polling_thread_entry.c ux_host_stack_initialize.c ux_host_stack_interface_endpoint_get.c ux_host_stack_interface_instance_create.c ux_host_stack_interface_instance_delete.c ux_host_stack_interface_set.c ux_host_stack_interface_setting_select.c ux_host_stack_interfaces_scan.c ux_host_stack_new_configuration_create.c ux_host_stack_new_device_create.c ux_host_stack_new_device_get.c ux_host_stack_new_endpoint_create.c ux_host_stack_new_interface_create.c ux_host_stack_rh_change_process.c ux_host_stack_rh_device_extraction.c ux_host_stack_rh_device_insertion.c ux_host_stack_role_swap.c ux_host_stack_tasks_run.c ux_host_stack_transfer_request.c ux_host_stack_transfer_request_abort.c ux_host_stack_transfer_run.c ux_host_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_trace_event_insert.c ux_trace_event_update.c ux_trace_object_register.c ux_trace_object_unregister.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/device hid class
    ../../eclipse_usbx/common/usbx_device_classes/inc/: ux_device_class_hid.h
    ../../eclipse_usbx/common/usbx_device_classes/src/: ux_device_class_hid_activate.c ux_device_class_hid_control_request.c ux_device_class_hid_deactivate.c ux_device_class_hid_descriptor_send.c ux_device_class_hid_entry.c ux_device_class_hid_event_get.c ux_device_class_hid_event_set.c ux_device_class_hid_initialize.c ux_device_class_hid_interrupt_thread.c ux_device_class_hid_read.c ux_device_class_hid_read_run.c ux_device_class_hid_receiver_event_free.c ux_device_class_hid_receiver_event_get.c ux_device_class_hid_receiver_initialize.c ux_device_class_hid_receiver_tasks_run.c ux_device_class_hid_receiver_thread.c ux_device_class_hid_receiver_uninitialize.c ux_device_class_hid_report_get.c ux_device_class_hid_report_set.c ux_device_class_hid_tasks_run.c ux_device_class_hid_uninitialize.c
