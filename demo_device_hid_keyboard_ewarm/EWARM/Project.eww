<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\usbx_device_hid_keyboard_rtos.ewp</path>
  </project>
  <batchBuild />
</workspace>
